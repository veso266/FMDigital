<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>H_D_Radio</value></param>
<param><key>title</key><value>Hybrid digital FM/DRM transmitter for BladeRF</value></param>
<param><key>author</key><value>Felix Wunsch (gr-drm), Jordan Johnson (IBOC/FM)</value></param>
<param><key>description</key><value>Allows an analog and digital radio signal to be produced.</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>station_label_2</value></param>
<param><key>value</key><value>"95.9 KXDT | Digital Two"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tp_2</value></param>
<param><key>value</key><value>drm.transm_params(RM, SO, False, 0, False, 2, 0, msc_prot_level_2, 0, 0, long_interl, audio_sample_rate, station_label_2, text_message_2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>text_message_2</value></param>
<param><key>value</key><value>"\x48\x65\x6c\x6c\x6f\x21\x20\x2f\x20\x48\x61\x6c\x6c\x6f\x21\x20\x2f\x20\xd0\x9f\xd1\x80\xd0\xb8\xd0\xb2\xd0\xb5\xd1\x82\x21\x20\x2f\x20\x21\xd8\xb3\xd9\x84\xd8\xa7\xd9\x85"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>text_message</value></param>
<param><key>value</key><value>"\x48\x65\x6c\x6c\x6f\x21\x20\x2f\x20\x48\x61\x6c\x6c\x6f\x21\x20\x2f\x20\xd0\x9f\xd1\x80\xd0\xb8\xd0\xb2\xd0\xb5\xd1\x82\x21\x20\x2f\x20\x21\xd8\xb3\xd9\x84\xd8\xa7\xd9\x85"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>station_label</value></param>
<param><key>value</key><value>"95.9 KXDT | Digital One"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RM</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SO</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_sample_rate</value></param>
<param><key>value</key><value>24000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>msc_prot_level_2</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>long_interl</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tp</value></param>
<param><key>value</key><value>drm.transm_params(RM, SO, False, 0, False, 2, 0, msc_prot_level_2, 0, 0, long_interl, audio_sample_rate, station_label, text_message)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_rate</value></param>
<param><key>value</key><value>288e3</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>tp.ofdm().M_TF()</value></param>
<param><key>vlen</key><value>tp.fac().N()</value></param>
</block>
<block>
<key>drm_mlc_4qam_vbvc</key>
<param><key>id</key><value>drm_mlc_4qam_vbvc_0_0</value></param>
<param><key>vlen_in</key><value>tp.fac().L()</value></param>
<param><key>vlen_out</key><value>tp.fac().N()</value></param>
<param><key>n_tailbits</key><value>drm.N_TAILBITS / drm.DENOM_MOTHER_CODE</value></param>
<param><key>denom_mother_code_rate</key><value>drm.DENOM_MOTHER_CODE</value></param>
<param><key>map_tab</key><value>tp.cfg().ptables().d_QAM4</value></param>
<param><key>interl_seq</key><value>tp.fac().bit_interl_seq_0_2()</value></param>
<param><key>bits_per_symbol</key><value>tp.fac().mod_order()</value></param>
<param><key>pp</key><value>tp.fac().punct_pat_0()</value></param>
<param><key>pp_tail</key><value>tp.fac().punct_pat_0()</value></param>
<param><key>gen_poly</key><value>(91, 121, 101, 91, 121, 101)</value></param>
</block>
<block>
<key>cell_mapping_vcvc</key>
<param><key>id</key><value>cell_mapping_vcvc_0</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>tp.ofdm().M_TF()</value></param>
<param><key>vlen</key><value>tp.msc().N_MUX()</value></param>
</block>
<block>
<key>drm_interleaver_vcvc</key>
<param><key>id</key><value>drm_interleaver_vcvc_0</value></param>
<param><key>interl_seq</key><value>tp.msc().cell_interl_seq()</value></param>
<param><key>long_interl</key><value>long_interl</value></param>
<param><key>depth</key><value>drm.INTL_DEPTH_DRM</value></param>
</block>
<block>
<key>drm_mlc_64qam_sm_vbvc</key>
<param><key>id</key><value>drm_mlc_64qam_sm_vbvc_0</value></param>
<param><key>vlen_in</key><value>tp.msc().L_MUX()</value></param>
<param><key>n_tailbits</key><value>drm.N_TAILBITS / drm.DENOM_MOTHER_CODE</value></param>
<param><key>denom_mother_code_rate</key><value>drm.DENOM_MOTHER_CODE</value></param>
<param><key>gen_poly</key><value>(91, 121, 101, 91, 121, 101)</value></param>
<param><key>vlen_out</key><value>tp.msc().N_MUX()</value></param>
<param><key>bits_per_symbol</key><value>tp.msc().mod_order()</value></param>
<param><key>map_tab</key><value>tp.cfg().ptables().d_QAM64SM</value></param>
<param><key>pp_0</key><value>tp.msc().punct_pat_0_2()</value></param>
<param><key>pp_0_tail</key><value>tp.msc().punct_pat_tail_0_2()</value></param>
<param><key>pp_1</key><value>tp.msc().punct_pat_1_2()</value></param>
<param><key>pp_1_tail</key><value>tp.msc().punct_pat_tail_2_2()</value></param>
<param><key>pp_2</key><value>tp.msc().punct_pat_2_2()</value></param>
<param><key>pp_2_tail</key><value>tp.msc().punct_pat_tail_1_2()</value></param>
<param><key>interl_seq_0_2</key><value>tp.msc().bit_interl_seq_0_2()</value></param>
<param><key>interl_seq_2_2</key><value>tp.msc().bit_interl_seq_2_2()</value></param>
<param><key>interl_seq_1_2</key><value>tp.msc().bit_interl_seq_1_2()</value></param>
<param><key>M_total</key><value>tp.msc().M_total()</value></param>
<param><key>part_len_bot</key><value>tp.msc().M_total()[2]</value></param>
<param><key>part_len_top</key><value>tp.msc().M_total()[0]</value></param>
<param><key>part_len_mid</key><value>tp.msc().M_total()[1]</value></param>
</block>
<block>
<key>drm_mlc_16qam_vbvc</key>
<param><key>id</key><value>drm_mlc_16qam_vbvc_0</value></param>
<param><key>vlen_in</key><value>tp.sdc().L()</value></param>
<param><key>vlen_out</key><value>tp.sdc().N()</value></param>
<param><key>n_tailbits</key><value>drm.N_TAILBITS/drm.DENOM_MOTHER_CODE</value></param>
<param><key>denom_mother_code_rate</key><value>drm.DENOM_MOTHER_CODE</value></param>
<param><key>gen_poly</key><value>(91, 121, 101, 91, 121, 101)</value></param>
<param><key>bits_per_symbol</key><value>tp.sdc().mod_order()</value></param>
<param><key>map_tab</key><value>tp.cfg().ptables().d_QAM16</value></param>
<param><key>pp_0</key><value>tp.sdc().punct_pat_0()</value></param>
<param><key>interl_seq_0_2</key><value>tp.sdc().bit_interl_seq_0_2()</value></param>
<param><key>interl_seq_1_2</key><value>tp.sdc().bit_interl_seq_1_2()</value></param>
<param><key>pp_1_tail</key><value>tp.sdc().punct_pat_tail_1()</value></param>
<param><key>pp_1</key><value>tp.sdc().punct_pat_1()</value></param>
<param><key>pp_0_tail</key><value>tp.sdc().punct_pat_tail_0()</value></param>
<param><key>M_total</key><value>tp.sdc().M_total()</value></param>
<param><key>part_len_top</key><value>tp.sdc().M_total()[0]</value></param>
<param><key>part_len_bot</key><value>tp.sdc().M_total()[1]</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>interp</key><value>240</value></param>
<param><key>decim</key><value>441</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>drm_mlc_4qam_vbvc</key>
<param><key>id</key><value>drm_mlc_4qam_vbvc_0_0_0</value></param>
<param><key>vlen_in</key><value>tp_2.fac().L()</value></param>
<param><key>vlen_out</key><value>tp_2.fac().N()</value></param>
<param><key>n_tailbits</key><value>drm.N_TAILBITS / drm.DENOM_MOTHER_CODE</value></param>
<param><key>denom_mother_code_rate</key><value>drm.DENOM_MOTHER_CODE</value></param>
<param><key>map_tab</key><value>tp_2.cfg().ptables().d_QAM4</value></param>
<param><key>interl_seq</key><value>tp_2.fac().bit_interl_seq_0_2()</value></param>
<param><key>bits_per_symbol</key><value>tp_2.fac().mod_order()</value></param>
<param><key>pp</key><value>tp_2.fac().punct_pat_0()</value></param>
<param><key>pp_tail</key><value>tp_2.fac().punct_pat_0()</value></param>
<param><key>gen_poly</key><value>(91, 121, 101, 91, 121, 101)</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>tp_2.ofdm().M_TF()</value></param>
<param><key>vlen</key><value>tp_2.msc().N_MUX()</value></param>
</block>
<block>
<key>cell_mapping_vcvc</key>
<param><key>id</key><value>cell_mapping_vcvc_0_0</value></param>
<param><key>tp</key><value>tp_2</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>tp_2.ofdm().M_TF()</value></param>
<param><key>vlen</key><value>tp_2.fac().N()</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>tp_2.ofdm().nfft()</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value></value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>drm_mlc_64qam_sm_vbvc</key>
<param><key>id</key><value>drm_mlc_64qam_sm_vbvc_0_0</value></param>
<param><key>vlen_in</key><value>tp_2.msc().L_MUX()</value></param>
<param><key>n_tailbits</key><value>drm.N_TAILBITS / drm.DENOM_MOTHER_CODE</value></param>
<param><key>denom_mother_code_rate</key><value>drm.DENOM_MOTHER_CODE</value></param>
<param><key>gen_poly</key><value>(91, 121, 101, 91, 121, 101)</value></param>
<param><key>vlen_out</key><value>tp_2.msc().N_MUX()</value></param>
<param><key>bits_per_symbol</key><value>tp_2.msc().mod_order()</value></param>
<param><key>map_tab</key><value>tp_2.cfg().ptables().d_QAM64SM</value></param>
<param><key>pp_0</key><value>tp_2.msc().punct_pat_0_2()</value></param>
<param><key>pp_0_tail</key><value>tp_2.msc().punct_pat_tail_0_2()</value></param>
<param><key>pp_1</key><value>tp_2.msc().punct_pat_1_2()</value></param>
<param><key>pp_1_tail</key><value>tp_2.msc().punct_pat_tail_2_2()</value></param>
<param><key>pp_2</key><value>tp_2.msc().punct_pat_2_2()</value></param>
<param><key>pp_2_tail</key><value>tp_2.msc().punct_pat_tail_1_2()</value></param>
<param><key>interl_seq_0_2</key><value>tp_2.msc().bit_interl_seq_0_2()</value></param>
<param><key>interl_seq_2_2</key><value>tp_2.msc().bit_interl_seq_2_2()</value></param>
<param><key>interl_seq_1_2</key><value>tp_2.msc().bit_interl_seq_1_2()</value></param>
<param><key>M_total</key><value>tp_2.msc().M_total()</value></param>
<param><key>part_len_bot</key><value>tp_2.msc().M_total()[2]</value></param>
<param><key>part_len_top</key><value>tp_2.msc().M_total()[0]</value></param>
<param><key>part_len_mid</key><value>tp_2.msc().M_total()[1]</value></param>
</block>
<block>
<key>drm_scrambler_vbvb</key>
<param><key>id</key><value>drm_scrambler_vbvb_0_2</value></param>
<param><key>block_len</key><value>tp_2.msc().L_MUX()</value></param>
</block>
<block>
<key>drm_audio_encoder_svb</key>
<param><key>id</key><value>drm_audio_encoder_svb_0_0</value></param>
<param><key>tp</key><value>tp_2</value></param>
<param><key>len_out</key><value>tp_2.msc().L_MUX()</value></param>
</block>
<block>
<key>drm_generate_fac_vb</key>
<param><key>id</key><value>drm_generate_fac_vb_0_0</value></param>
<param><key>tp</key><value>tp_2</value></param>
</block>
<block>
<key>drm_generate_sdc_vb</key>
<param><key>id</key><value>drm_generate_sdc_vb_0_0</value></param>
<param><key>tp</key><value>tp_2</value></param>
</block>
<block>
<key>drm_interleaver_vcvc</key>
<param><key>id</key><value>drm_interleaver_vcvc_0_0</value></param>
<param><key>interl_seq</key><value>tp_2.msc().cell_interl_seq()</value></param>
<param><key>long_interl</key><value>long_interl</value></param>
<param><key>depth</key><value>drm.INTL_DEPTH_DRM</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>fm_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>amp</key><value>0.7</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0_1</value></param>
<param><key>samp_rate</key><value>192000</value></param>
<param><key>device_name</key><value>FM</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>Take ST MPX output and modulate</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>DRM-A Should be the same as FM!</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>fm_rate</value></param>
<param><key>low_cutoff_freq</key><value>40e3</value></param>
<param><key>high_cutoff_freq</key><value>66e3</value></param>
<param><key>width</key><value>20e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>drm_mlc_16qam_vbvc</key>
<param><key>id</key><value>drm_mlc_16qam_vbvc_0_0</value></param>
<param><key>vlen_in</key><value>tp_2.sdc().L()</value></param>
<param><key>vlen_out</key><value>tp_2.sdc().N()</value></param>
<param><key>n_tailbits</key><value>drm.N_TAILBITS/drm.DENOM_MOTHER_CODE</value></param>
<param><key>denom_mother_code_rate</key><value>drm.DENOM_MOTHER_CODE</value></param>
<param><key>gen_poly</key><value>(91, 121, 101, 91, 121, 101)</value></param>
<param><key>bits_per_symbol</key><value>tp_2.sdc().mod_order()</value></param>
<param><key>map_tab</key><value>tp_2.cfg().ptables().d_QAM16</value></param>
<param><key>pp_0</key><value>tp_2.sdc().punct_pat_0()</value></param>
<param><key>interl_seq_0_2</key><value>tp_2.sdc().bit_interl_seq_0_2()</value></param>
<param><key>interl_seq_1_2</key><value>tp_2.sdc().bit_interl_seq_1_2()</value></param>
<param><key>pp_1_tail</key><value>tp_2.sdc().punct_pat_tail_1()</value></param>
<param><key>pp_1</key><value>tp_2.sdc().punct_pat_1()</value></param>
<param><key>pp_0_tail</key><value>tp_2.sdc().punct_pat_tail_0()</value></param>
<param><key>M_total</key><value>tp_2.sdc().M_total()</value></param>
<param><key>part_len_top</key><value>tp_2.sdc().M_total()[0]</value></param>
<param><key>part_len_bot</key><value>tp_2.sdc().M_total()[1]</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_1</value></param>
<param><key>input_size</key><value>tp.ofdm().nfft()</value></param>
<param><key>cp_len</key><value>tp.ofdm().nfft()/4</value></param>
<param><key>tagname</key><value></value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>taps</key><value>1e2</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>fm_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>76e3</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_1_0</value></param>
<param><key>input_size</key><value>tp_2.ofdm().nfft()</value></param>
<param><key>cp_len</key><value>tp_2.ofdm().nfft()/4</value></param>
<param><key>tagname</key><value></value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>taps</key><value>100</value></param>
</block>
<block>
<key>analog_wfm_tx</key>
<param><key>id</key><value>analog_wfm_tx_0_0</value></param>
<param><key>audio_rate</key><value>192000</value></param>
<param><key>quad_rate</key><value>192000*2</value></param>
<param><key>tau</key><value>0</value></param>
<param><key>max_dev</key><value>75e3</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>3</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0_0</value></param>
<param><key>samp_rate</key><value>44100</value></param>
<param><key>device_name</key><value>DRM-L</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0_0</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>fm_rate</value></param>
<param><key>low_cutoff_freq</key><value>40e3</value></param>
<param><key>high_cutoff_freq</key><value>66e3</value></param>
<param><key>width</key><value>20e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>0.06</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>0.0005</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>fm_rate</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>fm_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>5</value></param>
<param><key>y_divs</key><value>20</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>5</value></param>
<param><key>samp_rate</key><value>fm_rate</value></param>
<param><key>low_cutoff_freq</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>79e3</value></param>
<param><key>width</key><value>5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>gain</key><value>0.20</value></param>
<param><key>samp_rate</key><value>fm_rate</value></param>
<param><key>low_cutoff_freq</key><value>116e3</value></param>
<param><key>high_cutoff_freq</key><value>141e3</value></param>
<param><key>width</key><value>1e2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>file</key><value>/media/kyouko/Storage/drmtest2.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>288000</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1</value></param>
<param><key>note</key><value>READ NOTES B4 USE</value></param>
</block>
<block>
<key>drm_scrambler_vbvb</key>
<param><key>id</key><value>drm_scrambler_vbvb_0_0_0</value></param>
<param><key>block_len</key><value>tp_2.fac().L()</value></param>
</block>
<block>
<key>drm_scrambler_vbvb</key>
<param><key>id</key><value>drm_scrambler_vbvb_0_1_0</value></param>
<param><key>block_len</key><value>tp_2.sdc().L()</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>44100</value></param>
<param><key>device_name</key><value>DRM-R (Same as FM)</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>interp</key><value>240</value></param>
<param><key>decim</key><value>441</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>drm_audio_encoder_svb</key>
<param><key>id</key><value>drm_audio_encoder_svb_0</value></param>
<param><key>tp</key><value>tp</value></param>
<param><key>len_out</key><value>tp.msc().L_MUX()</value></param>
</block>
<block>
<key>drm_scrambler_vbvb</key>
<param><key>id</key><value>drm_scrambler_vbvb_0</value></param>
<param><key>block_len</key><value>tp.msc().L_MUX()</value></param>
</block>
<block>
<key>drm_scrambler_vbvb</key>
<param><key>id</key><value>drm_scrambler_vbvb_0_1</value></param>
<param><key>block_len</key><value>tp.sdc().L()</value></param>
</block>
<block>
<key>drm_generate_sdc_vb</key>
<param><key>id</key><value>drm_generate_sdc_vb_0</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>drm_generate_fac_vb</key>
<param><key>id</key><value>drm_generate_fac_vb_0</value></param>
<param><key>tp</key><value>tp</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>fm_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>106e3</value></param>
<param><key>amp</key><value>0.7</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>tp.ofdm().nfft()</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value></value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>drm_scrambler_vbvb</key>
<param><key>id</key><value>drm_scrambler_vbvb_0_0</value></param>
<param><key>block_len</key><value>tp.fac().L()</value></param>
</block>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>drm_audio_encoder_svb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_mlc_4qam_vbvc_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cell_mapping_vcvc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_interleaver_vcvc_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>cell_mapping_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>cell_mapping_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_scrambler_vbvb_0_0</source_block_id><sink_block_id>drm_mlc_4qam_vbvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_mlc_16qam_vbvc_0</source_block_id><sink_block_id>cell_mapping_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>drm_scrambler_vbvb_0_1</source_block_id><sink_block_id>drm_mlc_16qam_vbvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_generate_sdc_vb_0</source_block_id><sink_block_id>drm_scrambler_vbvb_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_generate_fac_vb_0</source_block_id><sink_block_id>drm_scrambler_vbvb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_audio_encoder_svb_0</source_block_id><sink_block_id>drm_scrambler_vbvb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_scrambler_vbvb_0</source_block_id><sink_block_id>drm_mlc_64qam_sm_vbvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_mlc_64qam_sm_vbvc_0</source_block_id><sink_block_id>drm_interleaver_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0</source_block_id><sink_block_id>drm_audio_encoder_svb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_mlc_4qam_vbvc_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cell_mapping_vcvc_0_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_interleaver_vcvc_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0</source_block_id><sink_block_id>cell_mapping_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1</source_block_id><sink_block_id>cell_mapping_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_scrambler_vbvb_0_0_0</source_block_id><sink_block_id>drm_mlc_4qam_vbvc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_mlc_16qam_vbvc_0_0</source_block_id><sink_block_id>cell_mapping_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>drm_scrambler_vbvb_0_1_0</source_block_id><sink_block_id>drm_mlc_16qam_vbvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_generate_sdc_vb_0_0</source_block_id><sink_block_id>drm_scrambler_vbvb_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_generate_fac_vb_0_0</source_block_id><sink_block_id>drm_scrambler_vbvb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_audio_encoder_svb_0_0</source_block_id><sink_block_id>drm_scrambler_vbvb_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_scrambler_vbvb_0_2</source_block_id><sink_block_id>drm_mlc_64qam_sm_vbvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>drm_mlc_64qam_sm_vbvc_0_0</source_block_id><sink_block_id>drm_interleaver_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0_1</source_block_id><sink_block_id>analog_wfm_tx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_2</source_block_id><sink_block_id>blocks_multiply_xx_0_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_2_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_1</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>band_pass_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_1_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_tx_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>band_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
